Properties of the parts of a building model (IFC4)

# File
Description: Außentemperaturfühler, PT 1000, herausgeführte Fühlerhülse, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9040170, Außentemperaturfühler, PT 1000, herausgeführte Fühlerhülse
In: Raum
Description: Die Außentemperaturfühler werden zur Temperaturerfassung im Außenbereich, im Feuchtraumbereich, in Kühl- und Gewächshäusern sowie im Industriebereich eingesetzt und sind besonders gegen Staub und Feuchte geschützt. Aufgrund der außenliegenden Fühlerhülse besitzt dieser Außenfühler ein sehr gutes Ansprechverhalten gegenüber Temperaturänderungen. Bei direkter Sonneneinstrahlung auf den Fühler ist die Verwendung eines Sonnenschutzes zu empfehlen.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9040170; ModelLabel: AFHP 1000; GlobalTradeItemNumber: 4050528037510; ProductURL: https://alre.de/produkt_G9040170
Pset_Specification - NominalLength: 0.102 m; NominalWidth: 0.058 m; NominalDepth: 0.034 m; NetWeight: 0.108
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Geeignet für Wandmontage: yes; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: 3; Ausführung des elektrischen Anschlusses: Schraubanschluss; Deckelbefestigung: Bajonettverschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Mit Befestigungsmaterial: no; Einsatzgebiet: außen; Geeignet für Flüssigkeiten: no; Geeignet für Gase: yes; Temperaturmessbereich: -30; Sensorelement innerhalb des Gehäuses: no; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: yes; Sensortyp: Pt1000; Gehäusehöhe: 102; Gehäusebreite: 58; Gehäusetiefe: 34; Festes Kabel am Sensor: no; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9040170.pdf
